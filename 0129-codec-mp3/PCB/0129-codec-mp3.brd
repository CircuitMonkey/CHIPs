File: 0129-codec-mp3/PCB/0129-codec-mp3.brd (EAGLE design)
At the start: 24 x 26 mm, 60 parts

Commit message: Various updates.
Routing:
- net GND: track 28.8 -> 28.2 mm
